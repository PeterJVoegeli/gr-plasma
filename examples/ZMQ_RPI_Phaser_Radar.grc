options:
  parameters:
    author: analog
    generate_options: qt_gui
    id: ZMQ_RPI_Phaser_Radar
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: phaser_phaser_radar_0
  id: phaser_phaser_radar
  parameters:
    rx_freq_key: core:rx_freq
    sample_rate: samp_rate
    sample_start_key: core:sample_start
    tx_freq_key: core:tx_freq
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://192.168.137.84:3001
    comment: Command Pull
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_1
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://192.168.137.84:2001
    comment: Tx Pull
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://192.168.137.84:5001
    comment: Rx Push
    timeout: '100'
  states: {}

connections:
- [phaser_phaser_radar_0, out, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, phaser_phaser_radar_0, control]
- [zeromq_pull_msg_source_1, out, phaser_phaser_radar_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
