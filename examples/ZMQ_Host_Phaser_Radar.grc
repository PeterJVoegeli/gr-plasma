options:
  parameters:
    generate_options: qt_gui
    id: ZMQ_Host_Phaser_Radar
    output_language: python
    title: ZMQ_Host_Phaser_Radar
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: n_pulse_cpi
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: Command
    msg: pmt.intern("Gain=x")
    period: '1000'
  states: {}
- name: plasma_cw_to_pulsed_0
  id: plasma_cw_to_pulsed
  parameters:
    prf: 10e3
    prf_key: radar:prf
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
  states: {}
- name: plasma_lfm_source_0
  id: plasma_lfm_source
  parameters:
    bandwidth: samp_rate/2
    bandwidth_key: radar:bandwidth
    duration_key: radar:duration
    label_key: core:label
    prf: '0'
    prf_key: radar:prf
    pulse_width: '10e-6'
    samp_rate: samp_rate
    sample_rate_key: core:sample_rate
    start_freq: '-samp_rate/4'
    start_freq_key: radar:start_freq
  states: {}
- name: plasma_pulse_doppler_0
  id: plasma_pulse_doppler
  parameters:
    backend: plasma.Device.CPU
    depth: '100'
    doppler_fft_size_key: doppler_fft_size
    n_pulse_cpi: n_pulse_cpi
    nfft: n_pulse_cpi
  states: {}
- name: plasma_pulse_to_cpi_0
  id: plasma_pulse_to_cpi
  parameters:
    n_pulse_cpi: n_pulse_cpi
    n_pulse_cpi_key: radar:n_pulse_cpi
  states: {}
- name: plasma_range_doppler_sink_0
  id: plasma_range_doppler_sink
  parameters:
    center_freq: center_freq
    center_freq_key: core:frequency
    depth: '1'
    detection_indices_key: detection_indices
    dynamic_range: '60'
    dynamic_range_key: dynamic_range
    n_matrix_col_key: n_matrix_col
    nrow: '128'
    prf_key: radar:prf
    pulsewidth_key: radar:duration
    samp_rate: samp_rate
    samp_rate_key: core:sample_rate
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://192.168.137.84:5001
    comment: Rx Pull
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://192.168.137.84:2001
    comment: Tx Push
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://192.168.137.84:3001
    comment: Command Push
    timeout: '100'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, zeromq_push_msg_sink_0_0, in]
- [plasma_cw_to_pulsed_0, out, zeromq_push_msg_sink_0, in]
- [plasma_lfm_source_0, out, plasma_cw_to_pulsed_0, in]
- [plasma_lfm_source_0, out, plasma_pulse_doppler_0, tx]
- [plasma_pulse_doppler_0, out, plasma_range_doppler_sink_0, in]
- [plasma_pulse_to_cpi_0, out, plasma_pulse_doppler_0, rx]
- [zeromq_pull_msg_source_0, out, plasma_pulse_to_cpi_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
